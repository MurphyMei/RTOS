# Keil uVision project 工程模板.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 工程模板 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user;.\APP;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\UCOSII\Config;.\UCOSII\Core;.\UCOSII\Port;.\APP\flash;.\APP\gui;.\APP\lcd;.\APP\malloc;.\APP\spi;.\APP\touch;.\APP\SysTick;.\MyTask;.\APP\LED;.\APP\蜂鸣器;.\APP\数码管;.\APP\ADC;.\APP\按键;.\APP\DS18B20;.\APP\AT24Cxx;.\APP\IIC(24C02);.\APP\RTC;.\MyTask;.\APP\红外遥控;.\APP\独立看门狗;.\APP\低功耗;.\APP\sd;.\APP\adx345;.\APP\SRAM;.\APP\DAC;.\APP\232串口;.\APP\RS485;.\APP\can
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c public.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group stdperiph_Drive
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_dac.c stm32f10x_usart.c stm32f10x_can.c
  group APP
    ./APP/flash/: flash.c
    ./APP/gui/: gui.c
    ./APP/lcd/: lcd_driver.c
    ./APP/spi/: spi.c
    ./APP/malloc/: malloc.c
    ./APP/touch/: touch.c
    ./APP/SysTick/: systick.c
    ./APP/LED/: led.c
    ./APP/蜂鸣器/: beep.c
    ./APP/数码管/: smg.c
    ./APP/ADC/: adc.c
    ./APP/按键/: key.c
    ./APP/DS18B20/: ds18b20.c
    ./APP/AT24Cxx/: AT24CXX.c
    ./APP/IIC(24C02)/: iic.c
    ./APP/RTC/: rtc.c
    ./APP/红外遥控/: hwjs.c
    ./APP/独立看门狗/: iwdg.c
    ./APP/低功耗/: lowpower.c
    ./APP/sd/: sd.c
    ./APP/adx345/: adx345.c
    ./APP/SRAM/: sram.c
    ./APP/DAC/: dac.c
    ./APP/232串口/: usart.c
    ./APP/RS485/: rs485.c
    ./APP/can/: can.c
  group ucosii-core
    ./UCOSII/Core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucosii-config
    ./UCOSII/Config/: includes.h os_cfg.h
  group ucosii-port
    ./UCOSII/Port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group MyTask
    ./MyTask/: start_task.c touch_task.c led_task.c beep_task.c smg_task.c adc_task.c key_task.c ds18b20_task.c eeprom_task.c rtc_task.c hwjs_task.c iwdg_task.c lowpower_task.c flash_task.c sd_task.c adx345_task.c sram_task.c dac_task.c usart_task.c rs485_task.c can_task.c
